# IAR project Try.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F10X_HD
  ICCARM.CCIncludePath2: Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\; Libraries\STM32F10x_StdPeriph_Driver\inc\; Libraries\FatFS\; User\FreeRTOS\; User\FreeRTOS\Source\include\; User\FreeRTOS\Source\portable\IAR\ARM_CM3\; User\; User\POLBUT_TASK\; User\MAIN_TASK\; User\Lcd_task\; User\Osc_Task\; User\Meas_Task\; User\Calc_Task\; User\SD_TASK\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: User\FreeRTOS\
  OBJCOPY.OOCOutputFile: Try.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: Try.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group CMSIS
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group EWARM6
    User/: startup_stm32f10x_hd.s
  group FatFS
    Libraries/FatFS/: fattime.c ff.c sd_spi_stm32.c
  group StdPeriph_Driver
    Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c
  group User
    User/: CommonDefines.h InterDefines.h main.c stm32f10x_it.c
  group User/Calc_Task
    User/Calc_Task/: Calc_Drv.c Calc_Task.c
  group User/FreeRTOS
    User/FreeRTOS/: FreeRTOSConfig.h
  group User/FreeRTOS/kernel
    User/FreeRTOS/Source/: list.c queue.c tasks.c
  group User/FreeRTOS/MemMang
    User/FreeRTOS/Source/portable/MemMang/: heap_1.c
  group User/FreeRTOS/portatable
    User/FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group User/LCD_TASK
    User/LCD_TASK/: LCD_Delay.s LCD_Drv.c LCD_Task.c
  group User/MAIN_TASK
    User/MAIN_TASK/: Menu_Drv.c Menu_Task.c
  group User/Meas_Task
    User/Meas_Task/: Meas_Drv.c Meas_Task.c
  group User/Osc_Thread
    User/Osc_Task/: Osc_Drv.c Osc_Task.c
  group User/POLBUT_TASK
    User/POLBUT_TASK/: PolBut_Drv.c PolBut_Task.c
  group User/SD_TASK
    User/SD_TASK/: SD_Drv.c SD_Task.c
