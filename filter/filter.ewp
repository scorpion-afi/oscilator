# IAR project filter.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F10X_HD
  ICCARM.CCIncludePath2: libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\; libraries\STM32F10x_StdPeriph_Driver\inc\; user\inc\; user\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: filter.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group cmsis
    libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group ewarm
    user/: startup_stm32f10x_hd.s
  group std_periph_driver
    libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c
  group user
    user/src/: main.c
    user/: stm32f10x_it.c
  group user/filtering
    user/src/: fir.c iir.c
